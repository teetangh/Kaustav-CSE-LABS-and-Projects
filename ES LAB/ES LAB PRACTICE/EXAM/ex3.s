	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY 
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=VAL1  
	LDR R1,=0    ;SUM
	LDR R2,=0    ;REM

	LDR R4,=0
	LDR R5,=0

	LDR R6,=0    ;Q
	LDR R7=0     ;R

	LDR R8,=0    ;MISC

LOOP
	CMP R0,#0
	BEQ STORE
	LDR R4,R0
	LDR R5,=10
	BL DIVIDE
	LDR R2,R7
	MUL R8,R2,R2
	MUL R8,R8,R8
	ADD R1,R1,R8
	LDR R8,=0
	LDR R4,R0
	LDR R5,=10
	BL DIVIDE
	LDR R0,R6
	B LOOP

DIVIDE
	LDR R9,R4
	CMP R9,R4
	BXLT LR
	SUB R9,R4
	ADD R6,#1
	LDR R7,R9
	B DIVIDE

STORE
	CMP R0,R1
	STREQ #0xFF,FINAL
	STRNE #0xAA,FINAL
STOP
	B STOP
VAL1 DCD 371
	AREA mydata,DATA,READWRITE
FINAL DCD 0
	END