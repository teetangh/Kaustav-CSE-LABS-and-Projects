	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode , CODE , READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM
	LDR R3,=UNPACK
	LDR R1,[R0]
	
LOOP
	CMP R1,#0xA
	BCC STORE
	SUB R1,R1,#0xA
	ADD R2,R2,#1
	B LOOP
	
STORE
	STRB R1,[R3],#1
	MOV R1,R2
	MOV R2,#0
	CMP  R1,#0xA
	BCS LOOP
	STRB R1,[R3]
	
	LDR R4,=UNPACK
	LDR R1,[R4]
	MOV R5,#3
	MOV R7,#0	;FILL IN THE BLANKS
	LDR R8,=PACK
	
LOOP2
	LDRB R6,[R4],#1
	LSL R7,R7,#4
	ORR R7,R7,R6
	SUBS R5,#1
	BNE LOOP2

	STR R7,[R8]

STOP
	B STOP
	ALIGN
NUM DCD 0xEF	;LOOKS KINDA FISHY;  USE 0xFF TO AVOID SUSPICION
	AREA mydata,DATA,READWRITE
UNPACK DCD 0
PACK DCD 0
	END
	


