	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000   
	DCD Reset_Handler
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=INPUT
	LDR R1,=RESULT
	LDR R2,[R0]
	BL FACT
	STR R2,[R1]
HERE
	B HERE
FACT
	PUSH {R3,LR}
ADDR
	MOV R3,R2
	CMP R2,#0
	BNE DOWN
	MOV R2,#1
	B DOWN1
DOWN
	SUB R2,#1
	BL FACT
	MUL R2,R3
DOWN1
	POP{R3,LR}
	BX LR
INPUT DCD 0X6	
	AREA mydata,DATA,READWRITE
RESULT DCD 0
	END