	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R0,#3
	MOV R1,#2
	MOV R2,#4
	MOV R3,#1
	MOV R4,#5
	STMIA R13!,{R0-R4}
	
	MOV R0,#4
	MOV R1,#1
	CMP R1,R0
	BHI L1
	
	MOV R2,R13
	MOV R3,R13
	MOV R4,#5
	ADD R5,R1,#1
	
L2	
	CMP R5,R4
	BHI SWAP
	LDMDB R3,{R6}
	SUB R3,R3,#4
	LDMDB R3,{R7}
	CMP R6,R7
	MOVCC R2,R3
	ADD	R5,#1
	B L2

SWAP
	LDMDB R2!,{R8}
	LDMDB R10!,{R9}
	STM R2,{R9}
	STM R10,{R8}
	
L1 LDMDB R13!,{R0,R4}
	END