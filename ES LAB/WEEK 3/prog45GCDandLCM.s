	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM1
	LDR R1,=NUM2
	LDR R2,=GCD
	LDR R3,=LCM
	LDR R4,[R0]
	LDR R5,[R1]
UP CMP R4,R5
	BEQ EXIT
	BCS NEXT
	SUB R5,R5,R4
	B UP
NEXT SUB R4,R4,R5
	B UP
EXIT STR R4,[R2]
	
	MUL R6,R0,R1 ;R6 = NUM1*NUM2
	MOV R7,R6 ;R7=R6
	MOV R8,#0
LOOP SUB R7,R2
	ADD R8
	BNE LOOP
STOP
	B STOP
	ALIGN
NUM1 DCD 4
NUM2 DCD 8
	AREA mydata,DATA,READWRITE
GCD DCD 0
LCM DCD 0
	END