	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	AREA hex_bcd,CODE,READONLY
	EXPORT Reset_Handler
	ENTRY
Reset_Handler
	LDR R6,=RES
	MOV R2,#0
	LDR R0,=VAL
	LDR R1,[R0]
UP
	CMP R1,#0xA
	BCC STORE
	SUB R1,#0xA
	ADD R2,#01
	B UP
STORE
	STRB R1,[R6],#1
	MOV R1,R2
	MOV R2,#0
	CMP R1,#0xA
	BCS UP
	STRB R1,[R6]
	LDR R6,=RES
	LDR R0,[R6]
	MOV R2,#0xF
	MOV R3,#0
	MOV R4,#4
LOOP
	AND R5,R0,R2
	LSL R2,#4
	LSR R0,#4
	ORR R3,R5
	SUBS R4,#1
	BNE LOOP
	STR R3,[R6]
STOP
	B STOP
VAL	DCD 0x21
	AREA mydata,DATA,READWRITE
RES DCD 0
	END