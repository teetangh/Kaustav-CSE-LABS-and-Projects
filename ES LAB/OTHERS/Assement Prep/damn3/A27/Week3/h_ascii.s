	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	AREA ascii,CODE,READONLY
	EXPORT Reset_Handler
	ENTRY
Reset_Handler
	LDR R6,=RES
	MOV R2,#0
	LDR R0,=VAL1
	LDR R1,[R0]
UP
	CMP R1,#0xA
	BCC STORE
	SUB R1,#0xA
	ADD R2,#01
	B UP
STORE
	ADD R1,#0x30
	STRB R1,[R6],#1
	MOV R1,R2
	MOV R2,#0
	CMP R1,#0xA
	BCS UP
	ADD R1,#0X30
	STRB R1,[R6]
STOP
	B STOP
VAL1	DCD 0x12B
	AREA mydata,DATA,READWRITE
RES	DCD 0
	END