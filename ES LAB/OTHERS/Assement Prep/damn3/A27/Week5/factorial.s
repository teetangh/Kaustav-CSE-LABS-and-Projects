	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	AREA factorial,CODE,READONLY
	EXPORT Reset_Handler
	ENTRY
Reset_Handler
	LDR R0,=SRC
	LDR R2,[R0]
	LDR R0,=DST
	BL FACT
	STR R2,[R0]
STOP
	B STOP
FACT
	PUSH {R3,LR}
	MOV R3,R2
	CMP R2,#0
	BNE DOWN
	MOV R2,#1
	B DOWN1
DOWN
	SUB R2,#1
	BL FACT
	MUL R2,R3
DOWN1
	POP {R3,LR}
	BX LR
SRC	DCD 6
	AREA mydata,DATA,READWRITE
DST DCD 0
	END