	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY 
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=VAL1
	LDR R1,=VAL2
	LDR R2,[R0]
	LDR R3,[R1]
	LDR R4,=GCD
	LDR R5,=LCM
UP12  CMP R2,R3
	BEQ EXIT
	BCS NEXT1
	BCC NEXT2
NEXT1
	SUB R2,R2,R3
	B UP12
NEXT2 
	SUB R3,R3,R2
	B UP12
EXIT 
	STR R2,[R4]
	LDR R6,[R0]
	LDR R7,[R1]
	MUL R7,R6,R7
UP  CMP R2,#1
	BEQ A1
	BCS A2
A1	
	STR R7,[R5]
A2
UP1	CMP R7,R2
	BCC ST1
	SUB R7,R7,R2
	ADD R8,#1
	B UP1
ST1	STR R8,[R5]
STOP
	B STOP
VAL1 DCD 6
VAL2 DCD 2
	AREA mydata,DATA,READWRITE
GCD DCD 0
LCM DCD 0
	END