	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM
	LDR R1,[R0]
	LDR R6,=RES
	MOV R2,#0XA
	MOV R5,#0
LOOP
	CMP R1,R2
	BCC ADD10
	SUB R1,R1,R2
	ADD R4,R4,#1
	B LOOP
ADD10	
	ADD R3,R1,#0X30
	STRB R3,[R6],#1
	MOV R1,R4
	CMP R1,R2
	BCS LOOP
	ADD R3,R1,#0X30
	STRB R3,[R6],#1
STOP
	B STOP
NUM DCD 12
	AREA mydata,DATA,READWRITE
RES DCD 0
	END