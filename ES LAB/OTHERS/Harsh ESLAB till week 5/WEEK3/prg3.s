	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N1
	LDR R1,[R0]
	LDR R0,=N2
	LDR R2,[R0]
	LDR R3,=QUO
	LDR R4,=REM
LOOP	CMP R1,R2
		BCC STORE
		SUB R1,R1,R2
		ADD R5,R5,#1
		B LOOP
STORE	STR R5,[R3]
		STR R1,[R4]
STOP
	B STOP
N1 DCD 11
N2 DCD 3
	AREA mydata,DATA,READWRITE
QUO DCD 0
REM DCD 0
	END