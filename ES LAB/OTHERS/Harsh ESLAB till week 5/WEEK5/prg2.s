	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM
	LDR R1,=RESULT
	MOV R3,#10
LOOP	LDR R2,[R0],#4
		STR R2,[R1]
		ADD R1,R1,#4
		SUB R3,R3,#1
		CMP R3,#0
		BNE LOOP
	LDR R1,=RESULT
	MOV R3,#0
	MOV R9,#10
L1 	ADD R4,R3,#1
	MOV R11,R1
	LDR R5,[R1]
	ADD R1,R1,#4
	MOV R6,R1
L2	LDR R7,[R6]
	CMP R7,R5
	MOVCC R5,R7
	MOVCC R8,R6
	ADD R6,R6,#4
	ADD R4,R4,#1
	CMP R4,R9
	BCC L2
	LDR R10,[R11]
	STR R5,[R11]
	STR R10,[R8]
	ADD R3,#1
	CMP R3,#9
	BCC L1
STOP B STOP
NUM DCD 10,9,8,7,6,5,4,3,2,1
	AREA mydata,DATA,READWRITE
RESULT DCD 0
	END