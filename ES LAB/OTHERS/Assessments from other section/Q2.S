	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10000000
	DCD Reset_Handler  
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N
	LDR R9,=DST
	LDR R1,[R0]
	MOV R2,R0
	MOV R6,#2
	MOV R7,#0
C
    BL DIV
	ADD R6,#1
	CMP R6,R1
	BNE C
	MOV R3,#1
	CMP R4,#0
	BEQ NOTPRIME
	STR R3,[R9]
	B STOP
NOTPRIME
    STR R4,[R9]
STOP
    B STOP
DIV
    MOV R4,R1
UP
    CMP R4,R6
	BCC NEXT
	SUB R2,R3
	B UP
NEXT
    BX LR
N DCD 5
	AREA mydata,DATA,READWRITE
DST DCD 0
	END
				
	

	