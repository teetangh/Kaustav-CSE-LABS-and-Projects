	AREA RESET , DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10000000
	DCD Reset_Handler
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R2,#0XA
	LDR R0,=SRC
	MOV R1,#0XABCD
GEN
	STR R1,[R0],#4
	ADD R1,#0XAB
	SUBS R2,#1
	BNE GEN
	
	LDR R0,=SRC
	MOV R2,#0XA
	LDR R1,=0X10001000
LOOP
	LDR R3,[R0]
	STR R3,[R1],#4
	ADD R0,#4
	SUBS R2,#1
	BNE LOOP
STOP
	B STOP
	AREA MYDATA, DATA, READWRITE
SRC DCD 0X10000000
DST DCD 0
	END