	AREA RESET , DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10000000
	DCD Reset_Handler
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N1
	LDR R1,=N2
	LDR R2,[R0]
	LDR R3,[R1]
	LDR R4,=GCD
	LDR R5,=LCM
UP  CMP R2,R3
	BEQ EXIT
	BCS NEXT
	SUB R3,R3,R2
	B UP
NEXT SUB R2,R2,R3
	B UP
EXIT STR R5,[R3]
STOP
	B STOP
N1 DCD 36
N2 DCD 18
	AREA MYDATA, DATA, READWRITE
GCD DCD 0
LCM DCD 0
	END