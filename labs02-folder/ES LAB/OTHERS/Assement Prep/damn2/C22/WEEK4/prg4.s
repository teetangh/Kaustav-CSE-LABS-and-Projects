	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM1
	LDR R6,=HEX1
	LDR R1,[R0]
	MOV R2,#0
	MOV R4,#1
	MOV R5,#10
L1	AND R3,R1,#0X0F
	MLA R2,R3,R4,R2
	MOVS R1,R1,LSR#04
	MUL R4,R4,R5
	BNE L1
	STR R2,[R6]
	LDR R0,=NUM2
	LDR R6,=HEX2
	LDR R1,[R0]
	MOV R2,#0
	MOV R4,#1
	MOV R5,#10
L2	AND R3,R1,#0X0F
	MLA R2,R3,R4,R2
	MOVS R1,R1,LSR#04
	MUL R4,R4,R5
	BNE L2
	STR R2,[R6]
	LDR R0,=HEX1
	LDR R1,[R0]
	LDR R0,=HEX2
	LDR R2,[R0]
	MUL R3,R1,R2
	MOV R1,R3
LOOP	CMP R1,#0XA
		BCC STORE
		SUB R1,R1,#0XA
		ADD R2,R2,#1
		B LOOP
STORE	STRB R1,[R3],#1
		MOV R1,R2
		MOV R2,#0
		CMP R1,#0XA
		BCS LOOP
		STRB R1,[R3]
	LDR R4,=UNPACK
	LDR R1,[R4]
	MOV R5,#3
	MOV R7,#0
	LDR R8,=PACK
LOOP1	LDRB R6,[R4],#1
		LSL R7,R7,#4
		ORR R7,R7,R6
		SUBS R5,#1
		BNE LOOP1
	STR R7,[R8]
STOP
	B STOP
NUM1 DCD 0X1299
NUM2 DCD 0X1599
	AREA mydata,DATA,READWRITE
HEX1 DCD 0
HEX2 DCD 0
UNPACK DCD 0
PACK DCD 0
	END