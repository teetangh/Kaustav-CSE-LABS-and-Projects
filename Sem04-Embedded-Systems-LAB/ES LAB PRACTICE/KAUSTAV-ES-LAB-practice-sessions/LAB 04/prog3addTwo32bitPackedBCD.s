	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode , CODE , READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM1
	LDR R1,[R0]
	LDR R0,=NUM2
	LDR R2,[R0]
	MOV R3,#0
	MOV R4,#8
	MOV R8,#0x0F
	LDR R9,=SUM

LOOP
	AND R5,R1,R8
	AND R6,R2,R8
	LSR R1,R1,#4
	LSR R2,R2,#4
	ADD R7,R6,R5
	ADD R7,R7,R3
	CMP R7,#0xA
	SUBCS R7,R7,#0xA
	MOVCS R3,#1
	MOVCC R3,#0
	STRB R7,[R9],#1
	SUBS R4,R4,#1
	BNE LOOP
	
	LDR R0,=SUM
	MOV R1,#0
	MOV R2,#8
	LDR R3,=PACK
	
LOOP2
	LDRB R4,[R0],#1
	LSL R1,R1,#4
	ORR R1,R1,#4
	SUBS R2,R2,#1
	BNE LOOP2
	
	STR R1,[R3]
	
STOP
	B STOP
	ALIGN
NUM1 DCD 0x00000129
NUM2 DCD 0x00000139
	AREA mydata,DATA,READWRITE
SUM DCD 0
PACK DCD 0
	END
	