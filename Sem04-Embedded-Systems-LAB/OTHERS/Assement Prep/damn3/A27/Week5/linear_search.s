	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	AREA linear_search,CODE,READONLY
	EXPORT Reset_Handler
	ENTRY
Reset_Handler
	LDR R0,=SRC
	LDR R1,=DST
	LDR R2,=KEY
	LDR R3,[R2]
	MOV R4,#0
	MOV R5,#0
LOOP
	LDR R5,[R0],#4
	CMP R5,R3
	BEQ NEXT
	ADD R4,#1
	CMP R4,#5
	BEQ NEXT1
	B LOOP
NEXT
	STR R4,[R1]
	B STOP
NEXT1
	MOV R4,#-1
	STR R4,[R1]
STOP
	B STOP
SRC	DCD 1,3,2,7,6
KEY	DCD 6
	AREA mydata,DATA,READWRITE
DST DCD 0
	END