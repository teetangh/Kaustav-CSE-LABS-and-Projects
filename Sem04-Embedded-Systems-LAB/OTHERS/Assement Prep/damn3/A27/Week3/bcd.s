	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	AREA bcd,CODE,READONLY
	EXPORT Reset_Handler
	ENTRY
Reset_Handler
	LDR R0,=0x01020304
	LDR R1,=RES
	MOV R2,#0x0000000F
	MOV R3,#0
	MOV R4,#4
UP
	AND R5,R0,R2
	LSL R2,#4
	LSR R0,#4
	ORR R3,R5
	SUBS R4,#1
	BNE UP
	STR R3,[R1]
STOP
	B STOP
	AREA mydata,DATA,READWRITE
RES	DCD 0
	END