	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
    LDR R0,=NUM
	MOV R1,=RES
	LDR R2,[R0]
UP 
    CMP R2,#0x0A
	BCC NEXT
	SUB R1,#0x0A
	ADD R3,#1
	B UP
NEXT
    ADD R2,#30
	STRB R1,[R6],#1
	MOV R1,R2
	MOV R2,#0
	CMP R1,#0x0A
	BCS UP
	ADD R1,#0x30
	STRB R1,[R6]
STOP
    B STOP
NUM DCD 0X52
	AREA MYDATA, DATA, READWRITE
RES DCD 0
	END