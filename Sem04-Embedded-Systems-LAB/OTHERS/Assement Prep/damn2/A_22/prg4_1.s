	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000   
		.
	DCD Reset_Handler
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R1,=SRC
	LDR R6,=DST
    MOV R2,R1
	BL FACT
	STORE HERE B HERE
FACT
	PUSH{R2,LR}
	MOV R2,R1
	CMP R1,#0
	MOVEQ R1,#1
	SUBNE R1,#1
	BLNE FACT
	POP {R3,LR}
	MOV R4,R3
	MUL R2,R4
	BX LR
SRC DCD 6
	AREA mydata,DATA,READWRITE
DST DCD 0
	END