	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	AREA Mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM
	LDR R1,[R0]
	LDR R3,=DST
ZERO
	MOV R2,#0
	CMP R1,#0XA
	BCC THREE
ONE	
	CMP R1,#0XA
	BCC TWO
	SUB R1,R1,#0XA
	ADD R2,R2,#1
	B ONE
TWO
	STR R1,[R3],#1
	MOV R1,R2
	B ZERO
THREE
	STR R1,[R3]
	LDR R0,=DST
	MOV R1,#4
	LDR R2,[R0]
	MOV R4,#0XF
	MOV R5,#0
FOUR
	CMP R1,#0
	BEQ FIVE
	AND R6,R2,R4
	LSR R2,R2,#4
	LSL R4,R4,#4
	ORR R5,R5,R6
	SUB R1,R1,#1
	B FOUR
FIVE
	STR R5,[R0]
STOP
	B STOP
NUM DCD 0Xf
	AREA mydata,DATA,READWRITE
DST DCD 0
	END