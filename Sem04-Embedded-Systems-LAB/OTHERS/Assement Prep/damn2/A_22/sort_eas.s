	AREA RESET, CODE, READONLY
	EXPORT __Vectors 
__Vectors	
	DCD 0X10000000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	MOV R0,#1
	MOV R1,#5
	MOV R2,#4
	MOV R3,#2
	MOV R4,#6
	MOV R5,#3
	MOV R6,#7
	MOV R7,#9
	MOV R8,#8
	MOV R9,#10
	STMEA R13!,{R0-R9}
	MOV R0,R13
L2
	MOV R1,R0
	MOV R3,R0
	SUB R3,#4
	ADD R11,R10,#1
L1
	LDMEA R3,{R4}
	LDMEA R1,{R7}
	CMP R4,R7
	BCC UP
	MOV R1,R3
UP	
	SUB R3,#4
	ADD R11,#1
	CMP R11,#10
	BNE L1
	LDMEA R0!,{R2}
	LDMEA R1!,{R6}
	
	STM R1,{R2}
	STM R0,{R6}
	ADD R10,#1
	CMP R10,#9
	BNE L2
	LDMEA R13!,{R0-R9}
STOP
	b STOP
	END