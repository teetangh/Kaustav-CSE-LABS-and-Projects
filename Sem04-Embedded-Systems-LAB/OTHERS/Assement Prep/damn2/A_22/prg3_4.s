	AREA RESET,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10000000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=VAL1
	LDR R1,[R0]
	LDR R7,[R0]
	LDR R0,=VAL2
	LDR R2,[R0]
	LDR R8,[R0]
	LDR R3,=GCD
	LDR R6,=LCM
LOOP	
	CMP R1,R2
	BEQ STORE
	BLT L1
	BGT L2
L1	
	SUB R2,R2,R1
	B LOOP
L2	
	SUB R1,R1,R2
	B LOOP
STORE
	STR R1,[R3]
	MUL R9,R7,R8
	CMP R1,#1
	BEQ STORE3
	B LC
LC	
	CMP R9,R1
	BLT STORE2
	SUB R9,R1
	ADD R5,#1
	B LC
STORE2 
	STR R5,[R6]
	B STOP
STORE3
	STR R9,[R6]
STOP
	B STOP
VAL1 DCD 12
VAL2 DCD 18
	AREA mydata,DATA,READWRITE
GCD DCD 0
LCM DCD 0
	END