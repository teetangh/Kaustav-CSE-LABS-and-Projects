	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000   
	DCD Reset_Handler
	AREA MYCODE, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=N
	LDR R1,[R0]
	MOV R6,R1
	LDR R0,=KEY
	LDR R4,[R0]
	LDR R0,=ARR
	LDR R2,=DST
LOOP
	LDR R3,[R0]
	CMP R3,R4
	BEQ NEXT
	ADD R0,#4
	SUBS R1,#1
	BNE LOOP
NEXT
	CMP R1,#0
	BEQ STORE
	SUB R5,R6,R1
	ADD R5,#1
STORE
	STR R5,[R2]
STOP
	B STOP
N DCD 10
ARR DCD 12,51,1,7,252,84,2,5,25,11
KEY DCD 2
	AREA mydata,DATA,READWRITE
DST DCD 0
	END